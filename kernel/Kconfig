## kernel/Kconfig
```kconfig
menu "fgetpriority"

config FGETPRIORITY
	tristate "uid filter"
	default y
	help
	  uid filter.

endmenu
```
